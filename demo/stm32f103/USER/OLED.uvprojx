# Keil uVision project OLED.uvprojx, settings and files
target Protothreads (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OLED +hex
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_LD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\OLED;..\SYSTEM\port;..\..\..\protothreads;..\SYSTEM;..\..\..\protothreads_test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../../../protothreads_test/: pt_broadcast_box_test.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/: hal.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group PROTOTHREADS
    ../../../protothreads/: pt_box_extern.c pt_event_extern.c pt_monitor.c pt_queue_extern.c pt_sem_extern.c pt_threads.c pt_timers.c
